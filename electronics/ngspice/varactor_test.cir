Varactor test

.include ../models/SMV2019079LF.lib
